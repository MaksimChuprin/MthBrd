# IAR project tft-3251.ewp, settings and files
configuration Inch32 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VE ST STM32F407VE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx; USE_PP; TFT32; __TFT_USER; __ARM__; __ETH_REMAP__
  ICCARM.CCIncludePath2: PROJ_DIR$\fitted cyclone; Setup; Application; CustomHID; $TOOLKIT_DIR$\INC\ST\; Y:\Programs\Service\PowerPac\RTOS\Inc; Y:\Programs\Service\Modbus; Y:\Programs\Service\EKSIS\; Y:\Programs\Service\ARM\common; Y:\Programs\Service\ARM\St\; Y:\Programs\Service\ARM\St\ST_HID\; Y:\Programs\Service\ARM\St\ST_TCP\; Y:\Programs\Service\ARM\STM32F4xx_HAL_Driver\Inc\; Y:\Programs\Service\ARM\cmsis\include\; Y:\Programs\Service\ARM\cmsis\Device\ST\STM32F4xx\Include\; Y:\Programs\Service\ARM\Middlewares\ST\STM32_USB_Device_Library\Core\Inc\; Y:\Programs\Service\ARM\cyclone_tcp\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: tft-32.hex
  ILINK.IlinkOutputFile: tft-3251.out
  ILINK.IlinkIcfFile: Setup\stm32f40x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Inch51 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx; USE_PP; TFT51; __TFT_USER; __ARM__
  OBJCOPY.OOCOutputFile: tft-51.hex
configuration Inch71 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx; USE_PP; TFT71; __TFT_USER; __ARM__
  OBJCOPY.OOCOutputFile: tft-71.hex
configuration led (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F407xx; USE_HAL_DRIVER; USE_PP; LED; __TFT_USER; __ARM__
  ICCARM.CCIncludePath2: PROJ_DIR$\fitted cyclone; Setup; Application; CustomHID; $TOOLKIT_DIR$\INC\ST\; Y:\Programs\Service\Modbus; Y:\Programs\Service\EKSIS\; Y:\Programs\Service\PowerPac\RTOS\Inc; Y:\Programs\Service\ARM\common; Y:\Programs\Service\ARM\St\; Y:\Programs\Service\ARM\St\ST_HID\; Y:\Programs\Service\ARM\St\ST_TCP\; Y:\Programs\Service\ARM\STM32F4xx_HAL_Driver\Inc\; Y:\Programs\Service\ARM\cmsis\include\; Y:\Programs\Service\ARM\cmsis\Device\ST\STM32F4xx\Include\; Y:\Programs\Service\ARM\Middlewares\ST\STM32_USB_Device_Library\Core\Inc\; Y:\Programs\Service\ARM\cyclone_tcp\
  OBJCOPY.OOCOutputFile: led.hex
  ILINK.IlinkOutputFile: led.out
  group App
    Application/: control.c eksis_bin_ip.c global_var.c led.c master.c OS_IP_task.c OS_MQTT_task.c OS_Start.c RTOSInit.c SD.c TFT_32.c TFT_51.c TFT_71.c UARTs_task.c USB_Task.c utilites.c web_server.c
  group App/Headers
    Application/: defines.h device_struct.h global_declaration.h global_var.h led.h master.h OS_IP_task.h OS_MQTT_task.h SD.h SD_CardHW.h TFT_32.h TFT_51.h TFT_71.h TFT_71_4ch.h UARTs_task.h USB_Task.h utilites.h
    ../../Service/EKSIS/: eksis.h
  group Drivers/CMSIS
    ../../Service/ARM/cmsis/include/: cmsis_iccarm.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
    ../../Service/ARM/cmsis/Device/ST/STM32F4xx/Include/: stm32f407xx.h stm32f4xx.h
  group Drivers/STM32F4xx HAL Driver
    ../../Service/ARM/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rtc.c stm32f4xx_ll_usb.c
  group Ethernet/Common
    ../../Service/ARM/common/: cpu_endian.c date_time.c str.c
  group Ethernet/Fitted Cyclone TCP
    ../../Service/ARM/St/ST_TCP/: dp83848.c IP_init_407.c net.c pp_rtos.c stm32f4x7_eth.c
  group Ethernet/Original CycloneTCP Sources
    ../../Service/ARM/cyclone_tcp/ipv4/: arp.c icmp.c igmp.c ipv4.c ipv4_frag.c
    ../../Service/ARM/cyclone_tcp/core/: bsd_socket.c ethernet.c ip.c net_mem.c nic.c socket.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c
    ../../Service/ARM/cyclone_tcp/dhcp/: dhcp_client.c dhcp_common.c dhcp_debug.c
    ../../Service/ARM/cyclone_tcp/dns/: dns_cache.c dns_client.c dns_common.c dns_debug.c
    ../../Service/ARM/cyclone_tcp/mqtt/: mqtt_client.c mqtt_client_misc.c mqtt_client_packet.c mqtt_client_transport.c
    ../../Service/ARM/cyclone_tcp/netbios/: nbns_client.c nbns_common.c nbns_responder.c
    ../../Service/ARM/cyclone_tcp/sntp/: sntp_client.c
  group Fonts
    Application/: tahoma10B.c tahoma19B.c tahoma22.c tahoma34.c tahoma43.c tahoma87.c
  group lib
    ../../Service/PowerPac/RTOS/Lib/: os7m_tl__r.a
  group modbus
    Application/: modbus_param.h
  group modbus/lib
    ../../Service/Modbus/: modbus.c modbus.h
  group Setup
    Setup/: net_config.h OS_Error.c RTOSVect.c stm32f40x_flash.icf stm32f4xx_hal_conf.h
  group USB/Current
    CustomHID/: usbd_conf.c usbd_customhid.c usbd_customhid_if.c usbd_desc.c
  group USB/STM32_USBD_Library/Core
    ../../Service/ARM/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
